# Keil uVision project Economic dispatch.uvprojx, settings and files
target stm32f103 (6160000::V6.16::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Economic dispatch
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Application
    ./: main.c
  group High Level APIs
    ./: lcd.c lcd.h system.c system.h
  group Low Level APIs
    ./: clocks.c clocks.h gpio.c gpio.h i2c.c i2c.h systick.c systick.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
