# Keil uVision project utility.uvprojx, settings and files
target stm32f1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: utility
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Main Application
    ./: main.c
  group Library
    ./: clocks.c clocks.h dma.c dma.h gpio.c gpio.h hc12.c hc12.h system.c system.h systick.c systick.h uart.c uart.h button.c button.h
software components: CMSIS:CORE 5.5.0, Device:Startup 1.0.0
